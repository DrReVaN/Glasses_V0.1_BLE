# Keil uVision project WB35Test.uvprojx, settings and files
target Smartglasses-application (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32WB35CEUxA STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: smartglasses-application +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WB35xx,GLASSES_VECTOR_OFFSET=0x10000
  c include: ../Core/Inc;   ../Drivers/STM32WBxx_HAL_Driver/Inc;   ../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32WBxx/Include;   ../Drivers/CMSIS/Include;   ../STM32_WPAN/App;   ../Utilities/lpm/tiny_lpm;   ../Middlewares/ST/STM32_WPAN;   ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread;   ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl;   ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci;   ../Middlewares/ST/STM32_WPAN/utilities;   ../Middlewares/ST/STM32_WPAN/ble/core;   ../Middlewares/ST/STM32_WPAN/ble/core/auto;   ../Middlewares/ST/STM32_WPAN/ble/core/template;   ../Middlewares/ST/STM32_WPAN/ble/svc/Inc;   ../Middlewares/ST/STM32_WPAN/ble/svc/Src;   ../Utilities/sequencer;   ../Middlewares/ST/STM32_WPAN/ble;   .\RTE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: application.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wb35xx_cm4.s
  group Application/User/Core
    ../Core/Src/: main.c app_entry.c app_debug.c hw_timerserver.c stm32_lpm_if.c stm32wbxx_it.c stm32wbxx_hal_msp.c
  group Drivers/STM32WBxx_HAL_Driver
    ../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_hsem.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_ble.c custom_stm.c custom_app.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Middlewares/STM32_WPAN
    ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: tl_mbox.c hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c
    ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
    ../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
    ../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
    ../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
    ../Middlewares/ST/STM32_WPAN/ble/svc/Src/: svc_ctl.c
  group Utilities
    ../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../Utilities/sequencer/: stm32_seq.c
  group Library
    ./: ssd1306.c ssd1306_fonts.c STM32_Cap1203.c
  group Smartglasses
    ../Core/Src/: glasses_ble.c glasses_core.c glasses_display.c glasses_app.c glasses_flash.c glasses_ota.c
    ../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_iwdg.c
target Smartglasses-bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32WB35CEUxA STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.0
  cpu: as above
  output: smartglasses-bootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WB35xx,SMARTGLASSES_BOOTLOADER,GLASSES_VECTOR_OFFSET=0
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: bootloader.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group left out of the first target's files
    ../Core/Src/: glasses_ble.c
software components: CMSIS:CORE 4.3.0
